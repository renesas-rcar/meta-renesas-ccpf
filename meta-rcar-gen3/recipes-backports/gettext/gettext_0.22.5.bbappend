FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
    file://0001-intl-Fix-build-failure-with-make-j.patch \
"

