PROVIDES:append = " virtual/libgl"

