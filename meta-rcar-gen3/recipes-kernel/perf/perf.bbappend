RDEPENDS:perf-tests:append = " bash"
